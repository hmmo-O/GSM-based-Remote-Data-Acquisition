# Keil uVision project gsm_agri_temp.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 Philips
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: gsm_temp +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: gsm_agri_temp.c
